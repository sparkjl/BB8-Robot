<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BB8_ctrl\BB8_ctrl.ewp</path>
  </project>
  <batchBuild/>
</workspace>


